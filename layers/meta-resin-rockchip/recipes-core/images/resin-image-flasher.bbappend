include resin-image.inc

# Overlays for capemgr
#RESIN_BOOT_PARTITION_FILES_append_marsboard-rk3066 = " uEnv.txt_internal:"
