include resin-image.inc

#IMAGE_INSTALL_append_rockchip = " bb-org-overlays"
